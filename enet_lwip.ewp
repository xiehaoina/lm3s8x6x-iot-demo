# IAR project enet_lwip.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LM3Sx9xx Luminary LM3Sx9xx
  ICCARM.CCDefines: ewarm; PART_LM3S8962
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: .; third_party\lwip-1.2.0\apps\httpd; third_party\lwip-1.2.0\src\include; third_party\lwip-1.2.0\src\include\ipv4; third_party\lwip-1.2.0\port; third_party\fatfs\src
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: ewarm
  AARM.AUserIncludes: .; ..\..\..\third_party\lwip-1.2.0\apps\httpd; ..\..\..\third_party\lwip-1.2.0\src\include; ..\..\..\third_party\lwip-1.2.0\src\include\ipv4; ..\..\..\third_party\lwip-1.2.0\port; ..\..\..\third_party\fatfs\src
  OBJCOPY.OOCOutputFile: enet_lwip.bin
  ILINK.IlinkOutputFile: enet_lwip.out
  ILINK.IlinkIcfFile: enet_lwip.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../../../src/ewarm/Exe/: driverlib.a
  group Source
    ../../../utils/: cspy.c ustdlib.c
    ../../../third_party/lwip-1.2.0/src/core/: dhcp.c inet.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
    ./: enet_lwip.c lmi_fs.c startup.c
    ../../../third_party/lwip-1.2.0/src/netif/: etharp.c
    ../../../third_party/fatfs/src/: ff.c
    ../../../third_party/lwip-1.2.0/apps/httpd/: httpd.c
    ../../../third_party/lwip-1.2.0/src/core/ipv4/: icmp.c ip.c ip_addr.c
    ../../../third_party/lwip-1.2.0/port/: luminaryif.c
    ../../../third_party/fatfs/port/: mmc-ek-lm3s8962.c
    ../: rit128x96x4.c
