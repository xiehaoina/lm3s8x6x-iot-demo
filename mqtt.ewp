# IAR project mqtt.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LM3Sx9xx Luminary LM3Sx9xx
  ICCARM.CCIncludePath2: $TOOLKIT_DIR$\INC\Luminary; .; third_party; third_party\lwip-1.2.0\apps\httpd; third_party\lwip-1.2.0\src\include; third_party\lwip-1.2.0\src\include\ipv4; third_party\lwip-1.2.0\port; third_party\mqtt-client\src\lm3sx
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  AARM.AUserIncludes: $TOOLKIT_DIR$\INC\Luminary; .; third_party; third_party\lwip-1.2.0\apps\httpd; third_party\lwip-1.2.0\src\include; third_party\lwip-1.2.0\src\include\ipv4; third_party\lwip-1.2.0\port; third_party\mqtt-client\src; third_party\mqtt-client\src\lm3sx; third_party\mqtt_packet\src
  OBJCOPY.OOCOutputFile: mqtt.srec
  ILINK.IlinkOutputFile: mqtt.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\Luminary\LM3S.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: dl-stnl0.a
  ICCARM.CCDefines: NDEBUG
  group (top)
    $EW_DIR$/ARM/inc/Luminary/utils/: ustdlib.c
  group Libraries
    $EW_DIR$/ARM/examples/Luminary/Stellaris/src/ewarm/Exe/: driverlib.a
  group Source
    $EW_DIR$/ARM/inc/Luminary/utils/: cspy.c
    third_party/lwip-1.2.0/src/core/: dhcp.c inet.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
    ./: enet_lwip.c lmi_fs.c startup.c
    third_party/lwip-1.2.0/src/netif/: etharp.c
    third_party/fatfs/src/: ff.c
    third_party/lwip-1.2.0/apps/httpd/: httpd.c
    third_party/lwip-1.2.0/src/core/ipv4/: icmp.c ip.c ip_addr.c
    third_party/lwip-1.2.0/port/: luminaryif.c
    third_party/fatfs/port/: mmc-ek-lm3s8962.c
    third_party/mqtt-client/src/: mqtt_client.c
    third_party/mqtt-client/src/lm3sx/: mqtt_lm3sx.c
    $EW_DIR$/ARM/inc/Luminary/: rit128x96x4.c
